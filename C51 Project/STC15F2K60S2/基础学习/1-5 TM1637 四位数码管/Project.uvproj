# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware;.\System;.\User
  group User
    ./: STARTUP.A51
    ./User/: main.c
  group Hardware
    ./Hardware/: ADC.c ADC.h OLED.c OLED.h OLED_Font.h DHT11.c DHT11.h TM1637.c TM1637.h
  group System
    ./System/: Delay.c Delay.h Sys.h
