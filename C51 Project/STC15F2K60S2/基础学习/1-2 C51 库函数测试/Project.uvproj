# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware;.\System;.\User;.\PARK
  group User
    ./: STARTUP.A51
    ./User/: main.c
  group Hardware
    ./Hardware/: OLED.c OLED.h OLED_Font.h
  group System
    ./System/: Sys.h
  group PARK
    ./PARK/: config.h STC15Fxxxx.H ADC.h ADC.c delay.h delay.c EEPROM.h EEPROM.c Exti.h Exti.c GPIO.h GPIO.c PCA.h PCA.c soft_uart.h Soft_UART.c USART.h USART.C timer.h timer.c
