# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware;.\System;.\User;C:\Keil_v5\C51\INC\STC
  group User
    ./: STARTUP.A51
    ./User/: main.c
  group Hardware
    ./Hardware/: OLED.c OLED.h OLED_Font.h DS1302.c DS1302.h
  group System
    ./System/: Delay.c Delay.h Sys.h
